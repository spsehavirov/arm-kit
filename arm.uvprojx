# Keil uVision project arm.uvprojx, settings and files
target source (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group examples
    ./examples/: example_01-builtinLED_01.c example_01-builtinLED_02-SysTick.c example_02-externalLED_01.c example_02-externalLED_02-SysTick.c example_03-userButton_01-controlLED.c example_04-LCD_01.c example_04-LCD_02-customChar.c example_05-KPAD_01.c
  group include
    ./include/: chrono.h LCD.h LCD_customChar_table.h KPAD.h
  group md
    ./: CHANGELOG.md README.md
  group src
    ./src/: assignments_for_better_practice.md main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
